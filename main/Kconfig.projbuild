## main/Kconfig.projbuild
```kconfig
menu "CrowMotion Configuration"

config CROWMOTION_BOARD_C3_SUPERMINI
    bool
    default y if IDF_TARGET_ESP32C3

endmenu
```
